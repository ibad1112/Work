.title PDiff Amp Testbench schematic

* MOSFET
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/nfet_01v8/sky130_fd_pr__nfet_01v8__tt.corner.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/nfet_01v8_lvt/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/pfet_01v8/sky130_fd_pr__pfet_01v8__tt.corner.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/nfet_03v3_nvt/sky130_fd_pr__nfet_03v3_nvt__tt.corner.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/nfet_05v0_nvt/sky130_fd_pr__nfet_05v0_nvt__tt.corner.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/esd_nfet_01v8/sky130_fd_pr__esd_nfet_01v8__tt.corner.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/pfet_01v8_lvt/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/pfet_01v8_hvt/sky130_fd_pr__pfet_01v8_hvt__tt.corner.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/esd_pfet_g5v0d10v5/sky130_fd_pr__esd_pfet_g5v0d10v5__tt.corner.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/pfet_g5v0d10v5/sky130_fd_pr__pfet_g5v0d10v5__tt.corner.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/pfet_g5v0d16v0/sky130_fd_pr__pfet_g5v0d16v0__tt.corner.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/nfet_g5v0d10v5/sky130_fd_pr__nfet_g5v0d10v5__tt.corner.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/nfet_g5v0d16v0/sky130_fd_pr__nfet_g5v0d16v0__tt_discrete.corner.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/esd_nfet_g5v0d10v5/sky130_fd_pr__esd_nfet_g5v0d10v5__tt.corner.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/models/corners/tt/nonfet.spice"
* Mismatch parameters
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/nfet_01v8/sky130_fd_pr__nfet_01v8__mismatch.corner.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/pfet_01v8/sky130_fd_pr__pfet_01v8__mismatch.corner.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/nfet_01v8_lvt/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/pfet_01v8_lvt/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/pfet_01v8_hvt/sky130_fd_pr__pfet_01v8_hvt__mismatch.corner.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/nfet_g5v0d10v5/sky130_fd_pr__nfet_g5v0d10v5__mismatch.corner.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/pfet_g5v0d10v5/sky130_fd_pr__pfet_g5v0d10v5__mismatch.corner.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/nfet_05v0_nvt/sky130_fd_pr__nfet_05v0_nvt__mismatch.corner.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/cells/nfet_03v3_nvt/sky130_fd_pr__nfet_03v3_nvt__mismatch.corner.spice"
* Resistor/Capacitor
.include "/home/merlproj/custom_tools/sky130_fd_pr/models/r+c/res_typical__cap_typical.spice"
.include "/home/merlproj/custom_tools/sky130_fd_pr/models/r+c/res_typical__cap_typical__lin.spice"
* Special cells
.include "/home/merlproj/custom_tools/sky130_fd_pr/models/corners/tt/specialized_cells.spice"
* All models
.include "/home/merlproj/custom_tools/sky130_fd_pr/models/all.spice"
* Corner
.include "/home/merlproj/custom_tools/sky130_fd_pr/models/corners/tt/rf.spice"

*Differential Amplifier
XMP1b1 DiffAmp1 AmpBias1 Vdd Vdd sky130_fd_pr__pfet_01v8_lvt w=7.5 l=5 m=1
XMP2b1 vbn Vcntrl DiffAmp1 DiffAmp1 sky130_fd_pr__pfet_01v8_lvt w=1 l=0.35
XMP3b1 Active DiffAmpPos DiffAmp1 DiffAmp1 sky130_fd_pr__pfet_01v8_lvt w=1 l=0.35
XMN1b1 vbn Active Vss Vss sky130_fd_pr__nfet_01v8 w=5 l=0.5 m=2
XMN2b1 Active Active Vss Vss sky130_fd_pr__nfet_01v8 w=5 l=0.5 m=2
XMPVb AmpBias1 AmpBias1 Vdd Vdd sky130_fd_pr__pfet_01v8_lvt w=7.5 l=5 m=1
I1 AmpBias1 0 10uA

V1 Vdd 0 dc 1.8
V2 Vss 0 dc 0
*V3 Vcntrl 0 dc 0.9
*V4 AmpBias1 0 dc 0.6
VP1 DiffAmpPos Vcntrl ac 1 sin(0 20m 100k)
VN1 Vcntrl 0 dc 800m

.param TEMP=27
	.control
	AC dec 1000 1 2G
	plot vdb(vbn) vdb(Active) vp(vbn)
	meas ac ymax max vdb(vbn)
	*tran 1p 30u 0
	*plot v(Vdd,DiffAmp1) v(Vdd,AmpBias1)
	*plot v(DiffAmp1,Active) v(DiffAmp1,DiffAmpPos)
	*plot v(DiffAmp1,vbn) v(DiffAmp1,Vcntrl)
	*plot v(Active) v(vbn)
	.endc

.end
